# IAR project ot_nrf52833_libopenthread_radio_nrf52833.ewp, settings and files
configuration libopenthread_radio_nrf52833 (ARM)
  General.OGChipSelectEditMenu: nrf52833_xxaa nRF52833_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DISABLE_CC310=1; FLOAT_ABI_HARD; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52833-mbedtls-config.h"; NRF52833_XXAA; OPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1; OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1; OPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1; OPENTHREAD_CONFIG_COAP_API_ENABLE=1; OPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1; OPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1; OPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1; OPENTHREAD_CONFIG_DIAG_ENABLE=1; OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_ECDSA_ENABLE=1; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1; OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1; OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1; OPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1; OPENTHREAD_CONFIG_JOINER_ENABLE=1; OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1; OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1; OPENTHREAD_CONFIG_NCP_UART_ENABLE=1; OPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_THREAD_VERSION=2; OPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1; OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1; OPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1; OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE="openthread-core-nrf52833-config-check.h"; OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0; OPENTHREAD_ENABLE_VENDOR_EXTENSION=0; OPENTHREAD_EXAMPLES_SIMULATION=0; OPENTHREAD_FTD=0; OPENTHREAD_MTD=0; OPENTHREAD_PLATFORM_POSIX=0; OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52833-config.h"; OPENTHREAD_RADIO=1; UART_AS_SERIAL_TRANSPORT=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\config; ..\..\..; ..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52833; ..\..\..\..\openthread\include; ..\..\..\..\openthread\src\core; ..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52833_libopenthread_radio_nrf52833.hex
  ILINK.IlinkOutputFile: ot_nrf52833_libopenthread_radio_nrf52833.out
  ILINK.IlinkIcfFile: ot_nrf52833_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../openthread/src/core/api/: diags_api.cpp heap_api.cpp instance_api.cpp link_raw_api.cpp logging_api.cpp random_noncrypto_api.cpp tasklet_api.cpp
    ../../../../openthread/src/core/diags/: factory_diags.cpp
    ../../../../openthread/src/core/common/: instance.cpp logging.cpp random_manager.cpp string.cpp tasklet.cpp timer.cpp
    ../../../../openthread/src/core/thread/: link_quality.cpp
    ../../../../openthread/src/core/mac/: link_raw.cpp mac_frame.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp
    ../../../../openthread/src/core/utils/: parse_cmdline.cpp
    ../../../../openthread/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp
