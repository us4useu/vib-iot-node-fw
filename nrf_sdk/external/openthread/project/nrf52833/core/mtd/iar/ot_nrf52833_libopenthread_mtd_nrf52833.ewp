# IAR project ot_nrf52833_libopenthread_mtd_nrf52833.ewp, settings and files
configuration libopenthread_mtd_nrf52833 (ARM)
  General.OGChipSelectEditMenu: nrf52833_xxaa nRF52833_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DISABLE_CC310=1; FLOAT_ABI_HARD; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52833-mbedtls-config.h"; NRF52833_XXAA; OPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1; OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1; OPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1; OPENTHREAD_CONFIG_COAP_API_ENABLE=1; OPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1; OPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1; OPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1; OPENTHREAD_CONFIG_DIAG_ENABLE=1; OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_ECDSA_ENABLE=1; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1; OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1; OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1; OPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1; OPENTHREAD_CONFIG_JOINER_ENABLE=1; OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1; OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1; OPENTHREAD_CONFIG_NCP_UART_ENABLE=1; OPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_THREAD_VERSION=2; OPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1; OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1; OPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1; OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE="openthread-core-nrf52833-config-check.h"; OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0; OPENTHREAD_ENABLE_VENDOR_EXTENSION=0; OPENTHREAD_EXAMPLES_SIMULATION=0; OPENTHREAD_FTD=0; OPENTHREAD_MTD=1; OPENTHREAD_PLATFORM_POSIX=0; OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52833-config.h"; OPENTHREAD_RADIO=0; UART_AS_SERIAL_TRANSPORT=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\config; ..\..\..; ..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52833; ..\..\..\..\openthread\include; ..\..\..\..\openthread\src\core; ..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52833_libopenthread_mtd_nrf52833.hex
  ILINK.IlinkOutputFile: ot_nrf52833_libopenthread_mtd_nrf52833.out
  ILINK.IlinkIcfFile: ot_nrf52833_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../openthread/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp child_table.cpp energy_scan_server.cpp indirect_sender.cpp key_manager.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_router.cpp mle_types.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_diagnostic.cpp panid_query_server.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp topology.cpp
    ../../../../openthread/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp ecdsa.cpp hmac_sha256.cpp mbedtls.cpp pbkdf2_cmac.cpp sha256.cpp
    ../../../../openthread/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_local.cpp dataset_manager.cpp dataset_manager_ftd.cpp dtls.cpp energy_scan_client.cpp joiner.cpp joiner_router.cpp meshcop.cpp meshcop_leader.cpp meshcop_tlvs.cpp panid_query_client.cpp timestamp.cpp
    ../../../../openthread/src/core/api/: backbone_router_api.cpp backbone_router_ftd_api.cpp border_router_api.cpp channel_manager_api.cpp channel_monitor_api.cpp child_supervision_api.cpp coap_api.cpp coap_secure_api.cpp commissioner_api.cpp crypto_api.cpp dataset_api.cpp dataset_ftd_api.cpp diags_api.cpp dns_api.cpp entropy_api.cpp heap_api.cpp icmp6_api.cpp instance_api.cpp ip6_api.cpp jam_detection_api.cpp joiner_api.cpp link_api.cpp link_raw_api.cpp logging_api.cpp message_api.cpp netdata_api.cpp netdiag_api.cpp network_time_api.cpp random_crypto_api.cpp random_noncrypto_api.cpp server_api.cpp sntp_api.cpp tasklet_api.cpp thread_api.cpp thread_ftd_api.cpp udp_api.cpp
    ../../../../openthread/src/core/utils/: channel_manager.cpp channel_monitor.cpp child_supervision.cpp flash.cpp heap.cpp jam_detector.cpp otns.cpp parse_cmdline.cpp slaac_address.cpp
    ../../../../openthread/src/core/mac/: channel_mask.cpp data_poll_handler.cpp data_poll_sender.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp
    ../../../../openthread/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
    ../../../../openthread/src/core/common/: crc16.cpp instance.cpp logging.cpp message.cpp notifier.cpp random_manager.cpp settings.cpp string.cpp tasklet.cpp timer.cpp tlvs.cpp trickle_timer.cpp
    ../../../../openthread/src/core/net/: dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp icmp6.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp netif.cpp sntp_client.cpp udp6.cpp
    ../../../../openthread/src/core/diags/: factory_diags.cpp
    ../../../../openthread/src/core/backbone_router/: leader.cpp local.cpp
    ../../../../openthread/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp
