# IAR project ot_nrf52840_libnordicsemi_nrf52840_radio_driver_softdevice.ewp, settings and files
configuration libnordicsemi_nrf52840_radio_driver_softdevice (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; ENABLE_FEM=1; FLOAT_ABI_HARD; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="nrf-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52840-mbedtls-config.h"; NRF52840_XXAA; NRF_802154_PROJECT_CONFIG="platform-config.h"; OPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1; OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1; OPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1; OPENTHREAD_CONFIG_COAP_API_ENABLE=1; OPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1; OPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1; OPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1; OPENTHREAD_CONFIG_DIAG_ENABLE=1; OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_ECDSA_ENABLE=1; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=0; OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1; OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1; OPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1; OPENTHREAD_CONFIG_JOINER_ENABLE=1; OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1; OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1; OPENTHREAD_CONFIG_NCP_UART_ENABLE=1; OPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_THREAD_VERSION=2; OPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1; OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1; OPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1; OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE="openthread-core-nrf52840-config-check.h"; OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0; OPENTHREAD_ENABLE_VENDOR_EXTENSION=0; OPENTHREAD_EXAMPLES_SIMULATION=0; OPENTHREAD_PLATFORM_POSIX=0; OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52840-config.h"; RAAL_SOFTDEVICE=1; S140; SOFTDEVICE_PRESENT; UART_AS_SERIAL_TRANSPORT=1; USE_APP_CONFIG=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52840; ..\..\..\..\openthread\include; ..\..\..\..\openthread\src\core; ..\..\..\..\openthread\third_party\NordicSemiconductor; ..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\openthread\third_party\NordicSemiconductor\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\config\nrf52840\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\fem; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\fem\three_pin_gpio; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features\ack_generator; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal\softdevice; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\block_dev; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\nrf_cc310_plat\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc; ..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers; ..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers\nrf52
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52840_libnordicsemi_nrf52840_radio_driver_softdevice.hex
  ILINK.IlinkOutputFile: ot_nrf52840_libnordicsemi_nrf52840_radio_driver_softdevice.out
  ILINK.IlinkIcfFile: ot_nrf52840_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_802154.c nrf_802154_core.c nrf_802154_core_hooks.c nrf_802154_critical_section.c nrf_802154_debug.c nrf_802154_notification_swi.c nrf_802154_pib.c nrf_802154_priority_drop_swi.c nrf_802154_request_swi.c nrf_802154_rssi.c nrf_802154_rx_buffer.c nrf_802154_swi.c nrf_802154_timer_coord.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/ack_generator/: nrf_802154_ack_data.c nrf_802154_ack_generator.c nrf_802154_enh_ack_generator.c nrf_802154_imm_ack_generator.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/clock/: nrf_802154_clock_ot.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/: nrf_802154_csma_ca.c nrf_802154_delayed_trx.c nrf_802154_filter.c nrf_802154_frame_parser.c nrf_802154_precise_ack_timeout.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fal/: nrf_802154_fal.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/hp_timer/: nrf_802154_hp_timer.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/rsch/: nrf_802154_rsch.c nrf_802154_rsch_crit_sect.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/timer_scheduler/: nrf_802154_timer_sched.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/coex/: nrf_802154_wifi_coex_none.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/three_pin_gpio/: nrf_fem_three_pin_gpio.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/rsch/raal/softdevice/: nrf_raal_softdevice.c
